## zephyr/Kconfig
```kconfig
config CSK6_SDHC_CLK_FREQ
    int "sdch clk frequency(Mhz) for csk6"
    default 25
    help
        "sdch clk frequency for csk6"

rsource "./heap/Kconfig"
```
